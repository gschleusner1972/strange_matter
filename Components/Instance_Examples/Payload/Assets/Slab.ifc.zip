Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: dbf4e41a-24dc-4a21-adb9-aae48d450440, NumberOfSaves: 65], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: DogLake], ExchangeRequirement [Architecture]
Time: 2023-08-28T17:56:51-05:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcSite, Default
RefLatitude: 44, 57, 23, 486022; RefLongitude: -94, -49, -13, -866577; RefElevation: 0 ft
Pset_SiteCommon - Reference: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1 (15)
Pset_BuildingStoreyCommon - Reference: Level 1
Name | LongName | Elevation (ft)
Basement 2 | Basement 2 | -40
Basement 1 | Basement 1 | -20
Level 1 | Level 1 | 0
Mez 1-2 | Mez 1-2 | 15
Level 3 - Wall Layouts 1 | Level 3 - Wall Layouts 1 | 31
Level 4 - Wall Layouts 2 | Level 4 - Wall Layouts 2 | 46
Level 4 - Wall Layouts 3 | Level 4 - Wall Layouts 3 | 61
Level 6 | Level 6 | 76
Level 7 | Level 7 | 91
Level 8 | Level 8 | 106
Level 9 | Level 9 | 121
Level 10 | Level 10 | 136
Level 11 | Level 11 | 151
Level 12 | Level 12 | 166
Level 13 | Level 13 | 185.5

# IfcOpeningElement, Floor:Structural Slab:71848
In: Level 8
PredefinedType: OPENING
Pset_EnvironmentalImpactIndicators - Reference: Structural Slab; sets with these values: 2

# IfcShadingDevice: Floor:Structural Slab, Floor:Structural Slab:71411
In: Level 8
Type - Material: Concrete
Type - Pset_ShadingDeviceCommon - IsExternal: no; Roughness: 1
Pset_EnvironmentalImpactIndicators - Reference: Structural Slab
Pset_ShadingDeviceCommon - Reference: Structural Slab
